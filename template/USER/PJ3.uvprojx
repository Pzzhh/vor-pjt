# Keil uVision project PJ3.uvprojx, settings and files
target release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: template +hex
  AfterMake: "F:\A0 陈老师\南科大电机 项目3 vor伺服\伺服电机项目3\vor-pjt\template\hex.bat"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550  --diag_suppress=188  --diag_suppress=167  --diag_suppress=668 --diag_suppress=1035
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\lvgl;..\lvgl\lsrc;..\lvgl\src\core;..\lvgl\src\draw;..\lvgl\src\font;..\lvgl\src\hal;..\lvgl\src\misc;..\lvgl\src\theme;..\lvgl\src\widgets;..\lvgl\src\extra;..\lvgl\src\extra\layouts;..\lvgl\src\extra\layout\flex;..\lv_port;..\lvgl\src\extra\layouts\flex;..\lvgl\src\extra\layouts\grid;..\lvgl\src\extra\libs;..\lvgl\src\extra\others;..\lvgl\src\extra\themes;..\lvgl\src\extra\widgets;..\lvgl\src\extra\themes\basic;..\;..\GUI;..\Motor;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\lvgl\src\extra\libs\qrcode;..\DataScope_DP;..\GUI;..\HARDWARE\WWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT5: ROM 0x8050000 size 0x150000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c touch.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SPI/: spi.c
    ../DataScope_DP/: DataScope_DP.C
    ../HARDWARE/WWDG/: wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_wwdg.c
  group lv_port
    ../lv_port/: lv_port_disp.c lv_port_indev.c
  group lv_core
    ../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lv_draw
    ../lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_extra
    ../lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/extra/widgets/chart/: lv_chart.c
    ../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/src/extra/widgets/led/: lv_led.c
    ../lvgl/src/extra/widgets/list/: lv_list.c
    ../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/extra/widgets/span/: lv_span.c
    ../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl/src/extra/: lv_extra.c
    ../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lvgl/src/extra/widgets/win/: lv_win.c
    ../lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group lv_font
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_hal
    ../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_widgets
    ../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group GUI
    ../GUI/: Gui.c list_c.c mytask.c
    ../: arrow_rotate_right.c
  group motor
    ../Motor/: Slave_motor.c motor_control.c
  group uart_slave
    ./: uart_slave.c
target debug (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: template +hex
  AfterMake: "F:\A0 冯梓安\南科大电机 项目3 vor伺服\伺服电机项目3\vor-pjt\template\hex.bat"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT5: ROM 0x8050000 size 0x150000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
